# Repository Th4nat0s/T2101_rack_control

File readme.md:

Temperature control for rack
============================

Read temperature and set the FAN accordly
-----------------------------------------
Read temperature via DS18B20  
Set the speed of the Fan accordly.  
Up to 16W / 12v  

### Attiny84  
SPI Through BusPirate 
arduino framework  

Warning: Flash on Board  
Buspirate set on 5v  
Additionnal power to 5v  
fuse flashed before mounting  

Tips
----
`./serial` launch serial console through buspirate  
`pio run -t fuses` set the fuses  
`pio run` process/build project from the current directory  
`pio run -t upload` - upload firmware to a target  
`pio run -t clean` - clean project (remove compiled files)  
`pio run -t upload -e release` upload release version without serial debug  
`pio platform update --dry-run` check for updates

## EAGLE design hardware/T2101_rack_control.brd

Parts:
C1: 0.1; C0603K
C2: 100; C0603K
C3: 4.7n; C0603K
D1: BLUE; LED-0603
D2: S1BB13F; DO-214AA
D3: DIODEDIODE-123FL; DIODE_SOD-123FL
GND, GND2: 2,54/1,1
H1, H2, H3, H4: MOUNT-PAD-ROUND3.0; 3,0-PAD
J6: CONN_06SMD_MALE; 1X06_SMD_MALE
Q1: IRFR220; TO252
Q2: 600mA/40V; SOT23-3
R1: 68; R0603
R2: 10k; R0603
R3: R-EU_R0603; R0603
R4, R5: 5k; R0603
T1: DS18B20; MAXIM_INTEGRATED_DS18B20+T&R_0
U1: ATTINY84; SO14
V: W237-02P; W237-132
VCC5, VCC12: 2,54/1,1

Connections:
DPOS: D1.A, R1.2
GND: C1.2, C2.2, C3.2, GND.1, GND2.1, H1.B3,0, H2.B3,0, H3.B3,0, H4.B3,0, J6.6, Q1.2 (S), Q2.2 (E), R2.1, T1.1 (GND), U1.14 (GND)
LED: R3.1, U1.13 ((PCINT0/AREF/ADC0)PA0)
MISO: J6.3, U1.5 ((PCINT10/INT0/OC0A/CKOUT)PB2), U1.8 ((PCINT5/OC1B/MISO/DO/ADC5)PA5)
MO: D2.A, Q1.3 (D), V.2
MOSI: J6.4, Q1.1 (G), R2.2, U1.7 ((PCINT6/OC1A/SDA/MOSI/ADC6)PA6)
unnamed: D1.C, Q2.3 (C)
unnamed: Q2.1 (B), R3.2
RST: C3.1, D3.A, J6.1, R5.2, U1.4 ((PCINT11/~RESET/DW)PB3)
SCL: J6.2, U1.9 ((PCINT4/T1/SCL/USCK/ADC4)PA4)
TMP: R4.2, T1.2 (DQ), U1.10 ((PCINT3/T0/ADC3)PA3)
VCC5: C1.1, C2.1, D3.C, J6.5, R1.1, R4.1, R5.1, T1.3 (VDD), U1.1 (VCC), VCC5.1
VCC12: D2.C, V.1, VCC12.1

Notes on the sheet:
Programmation

Board: 2 copper layers, 45.7 x 49.5 mm, 25 parts (0 on the bottom side), 13 nets.

## Commit log

2021-02-06 add hardware
2021-03-04 update tool
2021-03-04 updat hdw
2021-03-04 fix sheet ds18b
2021-03-07 blink on start
2021-03-15 Fixes schematic issues
2021-04-19 In prod

Notices in the files:
parts and their libraries:
SparkFun-DiscreteSemi: Licensing: Creative Commons ShareAlike 4.0 International - https://creativecommons.org/licenses/by-sa/4.0
